# Keil uVision project SH88F2051 TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH88F4051 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: SH88F2051 TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 hlk_rm04_demo_c51.c sh88f2052_uart.c HLK-M30.c
